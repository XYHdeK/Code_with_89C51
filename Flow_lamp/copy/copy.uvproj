# Keil uVision project copy.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: copy +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 copy.c
    ../../带参数的子程序/: dczcx.c
    ../ONE MORE TIME/: one more time.c
